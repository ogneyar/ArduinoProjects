# IAR project usbh_msc.ewp, settings and files
configuration GD32VF103 (RISCV, debug)
  General.GDeviceSelect: GD32VF103VBT6 GigaDevice GD32VF103VBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCDefines: GD32VF103V_EVAL; USE_USB_FS
  ICCRISCV.CCIncludePath2: ..\Include; ..\..\..\..\..\Firmware\GD32VF103_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32VF103_standard_peripheral; ..\..\..\..\..\Firmware\RISCV\drivers; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\RISCV\env_IAR; ..\fat_fs\inc; ..\..\..\..\..\Utilities\LCD_common; ..\..\..\..\..\Firmware\GD32VF103_usbfs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32VF103_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32VF103_usbfs_library\host\class\msc\Include; ..\..\..\..\..\Firmware\GD32VF103_usbfs_library\ustd\common; ..\..\..\..\..\Firmware\GD32VF103_usbfs_library\ustd\class\msc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Source/: app.c gd32vf103_it.c gd32vf103_usb_hw.c lcd_font.c lcd_log.c system_gd32vf103.c usbh_usr.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../fat_fs/src/: ff.c ffunicode.c
  group GD32VF103_EVAL
    ../../../../../Utilities/: gd32vf103v_eval.c gd32vf103v_lcd_eval.c
  group GD32VF103_Peripherals/Source
    ../../../../../Firmware/GD32VF103_standard_peripheral/Source/: gd32vf103_eclic.c gd32vf103_exmc.c gd32vf103_exti.c gd32vf103_gpio.c gd32vf103_pmu.c gd32vf103_rcu.c gd32vf103_timer.c gd32vf103_usart.c
  group RISCV/drivers
    ../../../../../Firmware/RISCV/drivers/: n200_func.c
  group RISCV/env_IAR
    ../../../../../Firmware/RISCV/env_IAR/: cstartup.s low_level_init.c
  group RISCV/stubs
    ../../../../../Firmware/RISCV/stubs/: write.c
  group USB_Class
    ../../../../../Firmware/GD32VF103_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../Firmware/GD32VF103_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32VF103_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
