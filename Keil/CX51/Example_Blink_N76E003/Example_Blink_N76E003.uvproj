# Keil uVision project Example_Blink_N76E003.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Example_Blink_N76E003 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\src
  group Source Group 1
    ./Code/: GPIO.C
  group Common
    ./src/: Common.c Delay.c
  group Startup
    ./src/: STARTUP.A51
