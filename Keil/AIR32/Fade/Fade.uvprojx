# Keil uVision project Fade.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fade +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:GPIO 1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.0, Device:StdPeriph Drivers:RCC 1.0.0
