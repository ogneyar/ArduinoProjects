# Keil uVision project hz.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hz +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./: main.c MDR32F9Q2I.h MDR32FxQI_port.h MDR32FxQI_rst_clk.h MDR32FxQI_port.c MDR32FxQI_rst_clk.c MDR32FxQI_config.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.2i
