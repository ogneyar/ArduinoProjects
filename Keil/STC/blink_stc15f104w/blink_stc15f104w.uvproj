# Keil uVision project blink_stc15f104w.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: blink_stc15f104w +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 main.c main.h
