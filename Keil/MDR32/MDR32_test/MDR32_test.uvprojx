# Keil uVision project MDR32_test.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDR32_test +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wgnu-binary-literal
  c include: .\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./main/: main.c
  group CMSIS
    ./CMSIS/: core_cm3.h MDR32F9Qx_board.h MDR32F9Qx_config.h MDR32F9Qx_lib.h MDR32Fx.h startup_MDR32F9Qx.s stdint.h system_MDR32F9Qx.c system_MDR32F9Qx.h
