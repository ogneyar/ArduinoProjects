# Keil uVision project uart_echo_terminal.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart_echo_terminal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.2i, Drivers:EEPROM 2.0.2i, Drivers:PORT 2.0.2i, Drivers:RST_CLK 2.0.2i, Drivers:UART 2.0.2i
