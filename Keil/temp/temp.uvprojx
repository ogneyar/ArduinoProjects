# Keil uVision project temp.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: \CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./Main/: main.c
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h MDR32F9Qx_board.h MDR32F9Qx_config.h MDR32F9Qx_lib.h MDR32Fx.h MDR32FxQI_eeprom.h MDR32FxQI_port.h MDR32FxQI_rst_clk.h MDR32FxQI_uart.h startup_MDR32F9Qx.s stdint.h
