# Keil uVision project Blink.uvprojx, settings and files
target Blink (6180000::V6.18::ARMCLANG)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blink +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\GD32\CMSIS;..\GD32\CMSIS\GD\GD32F30x\Include;..\GD32\GD32F30x_standard_peripheral\Include;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../Src/: gd32f30x_it.c main.c systick.c gpio.c
  group GD32F30x_Peripherals
    ../GD32/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../GD32/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group CMSIS
    ../GD32/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
