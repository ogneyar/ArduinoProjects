# Keil uVision project Blink.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.1.20.3
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1E000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Blink +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Main
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Driver:GPIO 1.6.0, Device:Driver:Port 1.6.0, Device:Startup 1.6.0
