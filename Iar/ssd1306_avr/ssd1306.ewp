# IAR project ssd1306.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m328p ATmega328P
  ICCAVR.newCCIncludePaths: $PROJ_DIR$; delay; display; display\fonts; spim; i2cm; ssd1306
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm328p.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: main.c main.h types.h
  group delay
    delay/: delay.c delay.h
  group display
    display/: disp1color.c disp1color.h
  group display/fonts
    display/fonts/: f10x16f.c f10x16f.h f6x8m.c f6x8m.h font.c font.h
  group i2cm
    i2cm/: i2cm.c i2cm.h
  group spim
    spim/: spim.c spim.h
  group ssd1306
    ssd1306/: ssd1306.c ssd1306.h
