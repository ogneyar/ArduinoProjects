<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>delay</name>
    <file>
      <name>$PROJ_DIR$\delay\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\delay\delay.h</name>
    </file>
  </group>
  <group>
    <name>display</name>
    <group>
      <name>fonts</name>
      <file>
        <name>$PROJ_DIR$\display\fonts\f10x16f.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\display\fonts\f10x16f.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\display\fonts\f6x8m.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\display\fonts\f6x8m.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\display\fonts\font.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\display\fonts\font.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\display\disp1color.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\display\disp1color.h</name>
    </file>
  </group>
  <group>
    <name>i2cm</name>
    <file>
      <name>$PROJ_DIR$\i2cm\i2cm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\i2cm\i2cm.h</name>
    </file>
  </group>
  <group>
    <name>spim</name>
    <file>
      <name>$PROJ_DIR$\spim\spim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\spim\spim.h</name>
    </file>
  </group>
  <group>
    <name>ssd1306</name>
    <file>
      <name>$PROJ_DIR$\ssd1306\ssd1306.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ssd1306\ssd1306.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\types.h</name>
  </file>
</project>


