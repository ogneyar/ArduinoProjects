# IAR project ssd1306.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; gpio; delay; display; display\fonts; i2cm; spim; ssd1306; STM32F10x_StdPeriph_Driver\inc; STM32F10x_StdPeriph_Driver\src; CMSIS; CMSIS\Core; CMSIS\Core\CM3\startup\iar; CMSIS\Core\CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ssd1306.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c main.h types.h
  group CMSIS
    CMSIS/Core/CM3/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c
    CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md.s
  group delay
    delay/: delay.c delay.h
  group display
    display/: disp1color.c disp1color.h
  group display/fonts
    display/fonts/: f10x16f.c f10x16f.h f6x8m.c f6x8m.h font.c font.h
  group gpio
    gpio/: gpio.c gpio.h
  group i2cm
    i2cm/: i2cm.c i2cm.h
  group spim
    spim/: spim.c spim.h
  group ssd1306
    ssd1306/: ssd1306.c ssd1306.h
  group STM32F10x_StdPeriph_Driver/inc
    STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32F10x_StdPeriph_Driver/src
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
